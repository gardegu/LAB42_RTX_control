Commit message: small adjustments

File: ROS_ws/src/ros_interface_umi_rtx/urdf/umi_rtx.urdf (robot description, URDF)
Before this commit: robot umi-rtx, 10 links, 9 joints
Joints:
- joint shoulder_updown: origin xyz=0.0445 0 -0.3 -> xyz=0 0.0445 -0.3 rpy=0 0 1.57
